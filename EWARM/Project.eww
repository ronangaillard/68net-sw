<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\68net.ewp</path>
  </project>
  <batchBuild />
</workspace>
